Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-08T15:34:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 15:34:59 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{4E7C03D2-7C75-4263-8FBB-6E5235F2B7E5}\ifc * Database version: 5507 * Database creation date: Wed Apr 08 15:34:58 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 15:34:59 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 15:34:59 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth, 6120FZ-104(2020):6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth:354651
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 96 mm
Type - Electrical(Type) - Bluetooth: 4.x; Electrical Connection: 9 / 12 V; Electronic Parts: Autofocus sensor;Solenoid valve;; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6120FZ-104(2020); ConvergoRefNr: 0087-2003-0016-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 02/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150095849; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6110300; Noise Class: I (ISO 3822); NRF Number: 4203701; VVS Number: 704276244
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/6120FZ-104; Catalog Drawing URL: http://static.oras.com/catdrw/6120FZ-104; Class: Touchless;Bluetooth®;Separate transformer;Green Building; Dimension Drawing URL: http://static.oras.com/dimdrw/6120FZ-104; FDV Document URL: http://www.oras.com/datasheet/6120FZ-104/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6120FZ-104; Group: Washbasin Faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;LTU;LVA;UKR; Model: 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; Name_en: 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Package Weight: 1.656 kg; Product Code: 6120FZ-104; Product Datasheet: http://www.oras.com/datasheet/6120FZ-104/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6120FZ-104; Product URL: http://static.oras.com/6120FZ-104; Type Name: 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth);Convertible for cold and premixed-water; Aerator: CASCADE®;Pressure controlled aerator; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; DN Size: DN15; Flow Rate At 300kPa With Flow Controller: 0.00211888 m3/s; Installation and Maintenance: http://static.oras.com/manual/6120FZ-104; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Non-return valve(s);Litter filter(s); Mounting Holes: 1 Mounting Hole; Protection Class: IP 55; Spare Parts: http://static.oras.com/sp/6120FZ-104; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Green Building; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6120FZ-104(2020); Features: Touchless;Bluetooth®;Separate transformer;Green Building; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6120FZ-104; Name: 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x140x120 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6120FZ-104; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.034902 m2; Volume: 0.00110126 m3
Identity Data - Mark: 17
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6120FZ-104(2020): 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; Family and Type: 6120FZ-104(2020): 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6120FZ-104(2020): 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; Type Id: 6120FZ-104(2020): 6120FZ-104 Washbasin faucet, 9/12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
